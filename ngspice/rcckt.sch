** sch_path: ngspice/rcckt.sch
**.subckt rcckt Vout Vin ref
*.opin Vout
*.ipin Vin
*.iopin ref
R1 Vout Vin 1k m=1
C1 Vout ref 1p m=1
**.ends
.end
